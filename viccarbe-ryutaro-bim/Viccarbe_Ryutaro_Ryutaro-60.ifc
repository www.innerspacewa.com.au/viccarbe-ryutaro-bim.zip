Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2016-05-30T12:48:11
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140223_1515(x64) - Exporter 15.6.0.0 - Alternate UI 15.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon May 30 12:48:11 2016 * Host: Bestia-01 * Database: C:\Users\CARLOS~1\AppData\Local\Temp\{EC787FFC-334E-4D56-A89C-FD247E8F8F64}\ifc * Database version: 5507 * Database creation date: Mon May 30 12:48:10 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon May 30 12:48:11 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon May 30 12:48:11 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nombre de proyecto; Phase: Estado de proyecto

# IfcSite, Default
RefLatitude: 40, 23, 59, 999999; RefLongitude: -3, -40, -59, -879999; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Propietario; Project Address: Introduzca dirección aquí; Project Issue Date: Fecha de emisión; Project Name: Nombre de proyecto; Project Number: 0001; Project Status: Estado de proyecto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Propietario; Project Address: Introduzca dirección aquí; Project Issue Date: Fecha de emisión; Project Name: Nombre de proyecto; Project Number: 0001; Project Status: Estado de proyecto

# IfcBuildingStorey, Nivel 1
LongName: Nivel 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Extremo inicial 8 mm; Family and Type: Level: Extremo inicial 8 mm; Type: Level: Extremo inicial 8 mm; Type Id: Level: Extremo inicial 8 mm
Identity Data - Type Name: Extremo inicial 8 mm; Building Story: yes; Name: Nivel 1; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: Extremo inicial de nivel - Círculo: Extremo inicial de nivel - Círculo; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcFurnishingElement: RYUTARO 60 (60x30x60 cm / 23.62"x11.81"x23.62"), 2015_Table_Viccarbe_Ryutaro:RYUTARO 60 (60x30x60 cm / 23.62"x11.81"x23.62"):132055
In: Nivel 1
Type - ElementType: RYUTARO 60 (60x30x60 cm / 23.62"x11.81"x23.62"); Material: Plastic, Red, Steel, Paint Finish, White, Lacquered MDF -Black
Type - Dimensions - Depth (inches): 23.62"; Depth (mm): 600 mm; Height (inches): 11.81"; Height (mm): 300 mm; Width (inches): 23.62"; Width (mm): 600 mm
Type - Identity Data - Bimetica: http://www.bimetica.com/; Collection: RYUTARO; Content Revision Date: 26/05/2016; Created by: Bimetica Parametric Design Services, S.L.; Description: Occasional table designed in a minimalist distinctive style. The steel legs are mortised through the top, creating an individual look. Thanks to the multiple finish options, the table can be used in numerous places. The tabletop is made of lacquered MDF or with an oak veneer in the various finishes offered by Viccarbe.; Designer: VICTOR CARRASCO; General Dimensions (inches): 23.62"x11.81"x23.62"; General Dimensions (mm): 600x300x600 mm; Information Expiry Date: 01/01/2017; Manufacturer: VICCARBE; Model: ROUND 60; OmniClass Number: 23.40.20.00; OmniClass Title: General Furniture and Specialties; Product Contact Email: info@viccarbe.com; Product Contact Telephone: +34 96 120 10 10; Product URL: http://www.viccarbe.com/product.php?id=464decbf77368ca; Reference Code: RYD60H30; Technical information: http://www.viccarbe.com/archivos/viccarbe-ryutaro-en-21.pdf; Terms and Conditions of Sale: See the conditions on the pricelist.; Type Name: RYUTARO 60 (60x30x60 cm / 23.62"x11.81"x23.62"); URL: http://www.viccarbe.com/; Warranty: 5 YEARS; Warranty URL: http://www.viccarbe.com/quality.php
Type - Materials and Finishes - Base Material: Steel, Paint Finish, White; Materials - Lacquers: http://www.viccarbe.com/archivos/VICCARBE_lacquers_lacados.pdf; Materials - Woods: http://www.viccarbe.com/archivos/VICCARBE_woods_maderas.pdf; Table Top Material: Lacquered MDF -Black; Tips Material: Plastic, Red
Type - Other - Category: Furniture; Diameter (mm): 600 mm; Family Name: 2015_Table_Viccarbe_Ryutaro; Legs Situation (mm): 60 mm; Legs Situation 2 (mm): 105.7 mm; Radius (mm): 300 mm
Pset_ManufacturerTypeInformation - Manufacturer: VICCARBE
Cantidades de mobiliario - Descripción de unidad: 2015_Table_Viccarbe_Ryutaro: RYUTARO 60 (60x30x60 cm / 23.62"x11.81"x23.62"); Tipo: 2015_Table_Viccarbe_Ryutaro: RYUTARO 60 (60x30x60 cm / 23.62"x11.81"x23.62"); Descripción: Occasional table designed in a minimalist distinctive style. The steel legs are mortised through the top, creating an individual look. Thanks to the multiple finish options, the table can be used in numerous places. The tabletop is made of lacquered MDF or with an oak veneer in the various finishes offered by Viccarbe.; Fabricante: VICCARBE; Modelo: ROUND 60; URL: http://www.viccarbe.com/
Constraints - Host: Level : Nivel 1; Level: Level: Nivel 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.334773 m2; Volume: 0.00422598 m3
Other - Family: 2015_Table_Viccarbe_Ryutaro: RYUTARO 60 (60x30x60 cm / 23.62"x11.81"x23.62"); Family and Type: 2015_Table_Viccarbe_Ryutaro: RYUTARO 60 (60x30x60 cm / 23.62"x11.81"x23.62"); Type: 2015_Table_Viccarbe_Ryutaro: RYUTARO 60 (60x30x60 cm / 23.62"x11.81"x23.62"); Type Id: 2015_Table_Viccarbe_Ryutaro: RYUTARO 60 (60x30x60 cm / 23.62"x11.81"x23.62")
Phasing - Phase Created: Fase 1
